# Keil uVision project CH4Switch.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: CW32L011K8 WHXY
  pack: WHXY.CW32L01x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CH4Switch +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\IdeSupport\MDK;..\Libraries\inc;..\USER\inc;..\code\gpio;..\code\key;..\code\led;..\code\sleep;..\code\timer;..\code\motor;..\code\adc;..\code\uart;..\code\i2c
  library: MicroLIB
  memory RVCT1: ROM 0x1000 size 0x7800
  memory RVCT2: ROM 0x8800 size 0x7800
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep=*Handler
  group APP
    ../code/timer/: all_task.c
    ../code/adc/: app_battery.c
    ../code/key/: app_key.c
    ../code/sleep/: app_sleep.c
    ../code/gpio/: app_io.c
    ../code/uart/: debug.c
  group BSP
    ../code/i2c/: bsp_i2c.c
    ../code/timer/: bsp_timer.c multi_timer.c
    ../code/gpio/: bsp_gpio.c
    ../code/adc/: bsp_adc.c
    ../code/key/: multi_button.c
  group User
    ../USER/src/: main.c interrupts_cw32l011.c
  group Driver
    ../Libraries/src/: cw32l011_atim.c cw32l011_sysctrl.c cw32l011_gpio.c cw32l011_adc.c cw32l011_btim.c cw32l011_gtim.c cw32l011_i2c.c
  group Startup
    ./: startup_cw32l011.s
    ../Libraries/src/: system_cw32l011.c
software components: CMSIS:CORE 5.6.0
